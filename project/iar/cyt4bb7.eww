<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project_config\cyt4bb7_cm_7_0.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\project_config\cyt4bb7_cm_7_1.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>cyt4bb7_cm_7_0</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>cyt4bb7_cm_7_1</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
