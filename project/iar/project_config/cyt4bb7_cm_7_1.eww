<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\cyt4bb7_cm_7_1.ewp</path>
    </project>
    <batchBuild />
</workspace>
